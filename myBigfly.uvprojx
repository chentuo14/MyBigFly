# Keil uVision project myBigfly.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: myBigfly +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,MPU9250,EMPL,EMPL_TARGET_STM32F1,USE_DMP
  c include: .\Hardware\H;.\Hardware\C;.\User;.\StartUp;.\Lib;.\Lib\inc;.\Lib\src;.\eMPL\driver\include;.\eMPL\driver\stm32L;.\eMPL\eMPL-hal;.\eMPL\mllite;.\eMPL\mpl;.\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c sysclock.c control.c ANO_DataTransfer.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c
  group Hardware
    ./Hardware/C/: led.c usart.c i2c.c ms5611.c pca9685.c tim2.c tim4.c wifi.c
  group eMPL
    ./eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu_userapi.c mpu_exti.c
    ./eMPL/eMPL-hal/: eMPL_outputs.c
    ./eMPL/mllite/: hal_outputs.c data_builder.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./eMPL/driver/stm32L/: log_stm32.c
    ./eMPL/mpl/: libmpllib.lib
